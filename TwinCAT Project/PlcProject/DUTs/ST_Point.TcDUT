TYPE ST_Point :
STRUCT
	x : INT;
	y : INT;
END_STRUCT
END_TYPE
